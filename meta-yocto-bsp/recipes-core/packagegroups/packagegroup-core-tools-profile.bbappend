RDEPENDS_${PN}_append_atom-pc = " lttng-ust systemtap"
RDEPENDS_${PN}_append_genericx86 = " lttng-ust systemtap"

