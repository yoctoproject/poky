KBRANCH_genericx86  = "v4.15/standard/base"
KBRANCH_genericx86-64  = "v4.15/standard/base"

KMACHINE_genericx86 ?= "common-pc"
KMACHINE_genericx86-64 ?= "common-pc-64"

SRCREV_machine_genericx86    ?= "a6a3a6a73d628798fc6eb6832bf829a9ea43f6bd"
SRCREV_machine_genericx86-64 ?= "a6a3a6a73d628798fc6eb6832bf829a9ea43f6bd"

COMPATIBLE_MACHINE_genericx86 = "genericx86"
COMPATIBLE_MACHINE_genericx86-64 = "genericx86-64"

LINUX_VERSION_genericx86 = "4.15.3"
LINUX_VERSION_genericx86-64 = "4.15.3"
