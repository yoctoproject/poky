KBRANCH_atom-pc  = "yocto/standard/common-pc/atom-pc"
KBRANCH_routerstationpro = "yocto/standard/routerstationpro"
KBRANCH_mpc8315e-rdb = "yocto/standard/fsl-mpc8315e-rdb"
KBRANCH_beagleboard = "yocto/standard/beagleboard"

SRCREV_machine_atom-pc ?= "834c2a69c87ee7211932f8ec5102a472828abcb1"
SRCREV_machine_routerstationpro ?= "1c17c082b6ee565acc176cde5be835ac4269817b"
SRCREV_machine_mpc8315e-rdb ?= "f2312437b52dda4499310aacb4c561ba8b8cbeb7"
SRCREV_machine_beagleboard ?= "3ab688a78cac7b2e32afc83376a53370f2bd13b7"


COMPATIBLE_MACHINE_mpc8315e-rdb = "mpc8315e-rdb"
COMPATIBLE_MACHINE_routerstationpro = "routerstationpro"
COMPATIBLE_MACHINE_beagleboard = "beagleboard"
COMPATIBLE_MACHINE_atom-pc = "atom-pc"
