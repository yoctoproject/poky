SDK-EXTRAS_atom-pc ?= " lttng-ust-dev"
SDK-EXTRAS_genericx86 ?= " lttng-ust-dev"
