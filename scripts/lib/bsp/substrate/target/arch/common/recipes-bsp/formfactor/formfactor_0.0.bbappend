FILESEXTRAPATHS_prepend_{{=machine}} := "${THISDIR}/${PN}:"
 
PRINC = "1"
