RRECOMMENDS_task-core-tools-profile_append_{{=machine}} = " systemtap"

