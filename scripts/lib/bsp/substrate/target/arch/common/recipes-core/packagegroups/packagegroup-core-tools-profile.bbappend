RRECOMMENDS_packagegroup-core-tools-profile_append_{{=machine}} = " systemtap"

