FILESEXTRAPATHS_prepend_{{=machine}} := "${THISDIR}/${PN}:"
