SUMMARY = "Example recipe for minha-camada"
DESCRIPTION = "This is an example recipe file."
LICENSE = "MIT"

# You can add your recipe content here
# Example: inherit autotools
# PV = "1.0"
