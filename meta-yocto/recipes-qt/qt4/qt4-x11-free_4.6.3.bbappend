QT_GLFLAGS_atom-pc = "-opengl"

