QT_GLFLAGS_atom-pc = "-opengl"
QT_GLFLAGS_mpc8315e-rdb = "-opengl"
