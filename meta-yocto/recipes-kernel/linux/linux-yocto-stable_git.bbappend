KMACHINE_atom-pc  = "atom-pc"
KMACHINE_routerstationpro = "routerstationpro"
KMACHINE_mpc8315e-rdb = "fsl-mpc8315e-rdb"
KMACHINE_beagleboard = "beagleboard"

SRCREV_machine_atom-pc = "72ca49ab08b8eb475cec82a10049503602325791"
SRCREV_machine_routerstationpro = "49745cd45c92a89e70c6e2334caa80818c134562"
SRCREV_machine_mpc8315e-rdb = "a1c0ed6bf4060c10874b2a8547d81b3169dcf16a"
SRCREV_machine_beagleboard = "ef7f944e773950d4016b7643f9ecf052bbe250cd"

COMPATIBLE_MACHINE += "(atom-pc|routerstationpro|mpc8315e-rdb|beagleboard)"

