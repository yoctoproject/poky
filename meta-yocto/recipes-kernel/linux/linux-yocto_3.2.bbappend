KMACHINE_atom-pc  = "atom-pc"
KMACHINE_routerstationpro = "routerstationpro"
KMACHINE_mpc8315e-rdb = "fsl-mpc8315e-rdb"
KMACHINE_beagleboard = "beagleboard"

KBRANCH_atom-pc  = "standard/default/common-pc/atom-pc"
KBRANCH_routerstationpro = "standard/default/routerstationpro"
KBRANCH_mpc8315e-rdb = "standard/default/fsl-mpc8315e-rdb"
KBRANCH_beagleboard = "standard/default/beagleboard"

SRCREV_machine_atom-pc ?= "624509ef194d14aa498ed6f1620093b8e40e3a30"
SRCREV_machine_routerstationpro ?= "6eb6f908bbca493bbce4b7c460f8bf07272a78a9"
SRCREV_machine_mpc8315e-rdb ?= "bd08c2cdee3c980060ee6d3206ece374570f74d2"
SRCREV_machine_beagleboard ?= "ab826acad523e8858dcf867847a732c7288b5dc7"

COMPATIBLE_MACHINE_mpc8315e-rdb = "mpc8315e-rdb"
COMPATIBLE_MACHINE_routerstationpro = "routerstationpro"
COMPATIBLE_MACHINE_beagleboard = "beagleboard"
COMPATIBLE_MACHINE_atom-pc = "atom-pc"
