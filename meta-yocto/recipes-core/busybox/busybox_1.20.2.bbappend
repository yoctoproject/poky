FILESEXTRAPATHS_prepend := "${THISDIR}/${P}:"

