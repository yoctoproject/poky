FILESEXTRAPATHS_prepend_poky := "${THISDIR}/${P}:"

