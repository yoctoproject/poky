FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

PRINC = "1"

