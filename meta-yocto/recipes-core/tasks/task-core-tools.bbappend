RDEPENDS_task-core-tools-profile_append_atom-pc = " lttng-ust systemtap"

